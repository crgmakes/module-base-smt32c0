File: pcb/requirements.kicad_sch (KiCad schematic)
At the start: 10 parts

Commit message: Added guard ring
Optimized layout
Parts:
- LOGO1, LOGO2, LOGO3, LOGO5, LOGO6: value ~ -> (none)
